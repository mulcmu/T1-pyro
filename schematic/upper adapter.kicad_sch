File: schematic/upper adapter.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: updates for load cell
Other:
- note added: "Fancy right angle adapter..."
